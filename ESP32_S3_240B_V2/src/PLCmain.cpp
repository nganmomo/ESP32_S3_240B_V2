#include "plcsvg.h"
#include "staticpromipcw.h"
#include "filehandle.h"
#include "helppopup.h"
#include "home.h"
#include "mobile.h"
#include "mqsetup.h"
#include "phone.h"
//#include "qrcode.h"
//#include "esp_timer.h"
//#include "img_converters.h" 
//#include "fb_gfx.h"
#include "soc/soc.h"             // disable brownout problems
#include "soc/rtc_cntl_reg.h"    // disable brownout problems
#include "esp_http_server.h"
//////////HW COUNTER///////
//const int counterPin = 7;  // Replace with the GPIO pin you want to use as the counter input
//volatile int counterValue = 0;
//////////HW COUNTER///////
uint16_t uartmaster(int length); 
void SerialRTXLoop(char* buffer,byte length);
void coolboot();
void ioinit(byte type);
void downloadinit();
// Replace with your network credentials
const char* ssid =""; //"ATT3jl8Tns";
const char* password ="";//"6mrk8iyf26vn";
char mssid[20];
char mpass[20];
byte setupmode=0;
//Serialloop
byte Serialmode;
byte Srxcount;
char SRXbuffer[255];
char STXbuffer[255];
////////////////
uint16_t connectcount=0;
byte Deviceinit=0;
byte buttonnum=0;
byte buttonmode;
byte Pinout[8]={Pout1,Pout2,Pout3,Pout4,Pout5,Pout6,Pout7,Pout8};
byte Pinin[8]={Pin1,Pin2,Pin3,Pin4,Pin5,Pin6,Pin7,Pin8};
byte analogpin[5]={Ain0,Ain1,Ain2,Ain3,Ain4};
//byte analogpout[5]={Aout0,Aout1,Aout2,Aout3,Aout4};

String MYSSID = "";
String MYPASSWORD = "";


#define PART_BOUNDARY "123456789000000000000987654321"
int8_t  Endigitalread = 0;
int8_t  Runmode = 1;
int8_t  mqttrun = 1;
byte    mqtten=0;
uint16_t dataz0[6][40];//0  sign 16
uint16_t dataz1[6][40];//1  id    32
uint16_t dataz2[6][40];//2  link  32
uint16_t dataz3[6][40];//3  line  16
uint16_t dataz4[6][40];//4  set   32
char     dataz100g6[100];//4  set   32
char     dataz100g7[100];//4  set   32
boxstate BoxState[6][40];
int64_t keypassword=0;
int64_t timeloop=10000000;//10000000
static const char* _STREAM_CONTENT_TYPE = "multipart/x-mixed-replace;boundary=" PART_BOUNDARY;
static const char* _STREAM_BOUNDARY = "\r\n--" PART_BOUNDARY "\r\n";
static const char* _STREAM_PART = "Content-Type: image/jpeg\r\nContent-Length: %u\r\n\r\n";

//////////HW COUNTER///////
//void IRAM_ATTR counterInterruptHandler() { 
//counterValue++;  // Increment the counter value on each interrupt  
//if(counterValue>10) digitalWrite(42,ON);
//if(counterValue>20) {digitalWrite(42,OFF);
//counterValue=0;}
//}
//////////HW COUNTER///////


httpd_handle_t controller_httpd = NULL;
httpd_handle_t stream_httpd = NULL;
void saveint16(char *variable,uint16_t (*dataz)[40],byte start,byte end);
//step2
static esp_err_t index_handler_phone(httpd_req_t *req){
  httpd_resp_set_type(req, "text/html");  
  return httpd_resp_send(req, (const char *)INDEX_HTML_phone, strlen(INDEX_HTML_phone));//8088 mobile phone/
}

static esp_err_t index_handler_plc(httpd_req_t *req){
  httpd_resp_set_type(req, "text/html");
  return httpd_resp_send(req,(const char *)INDEX_HTML_PLC, strlen(INDEX_HTML_PLC));//8088/PLC main enter 
}

static esp_err_t index_handler_filehandle(httpd_req_t *req){
  httpd_resp_set_type(req, "text/html");
  return httpd_resp_send(req,(const char *)INDEX_HTML_filehandle, strlen(INDEX_HTML_filehandle));//8088/PLC main enter 
}

static esp_err_t index_handler_mqsetup(httpd_req_t *req){
  httpd_resp_set_type(req, "text/html");    
  return httpd_resp_send(req, (const char *)INDEX_HTML_mqsetup, strlen(INDEX_HTML_mqsetup));//8088/KEYS keyboard /
}

static esp_err_t index_handler_mobile(httpd_req_t *req){
  httpd_resp_set_type(req, "text/html");    
  return httpd_resp_send(req, (const char *)INDEX_HTML_mobile, strlen(INDEX_HTML_mobile));//8088/KEYS keyboard /
}

//static esp_err_t index_handler_qrcode(httpd_req_t *req){
//  httpd_resp_set_type(req, "text/html");    
//  return httpd_resp_send(req, (const char *)INDEX_HTML_qrcode, strlen(INDEX_HTML_qrcode));//8088/KEYS keyboard /
//}

static esp_err_t index_handler_helppopup(httpd_req_t *req){
  httpd_resp_set_type(req, "text/html");    
  return httpd_resp_send(req, (const char *)INDEX_HTML_helppopup, strlen(INDEX_HTML_helppopup));//8088/KEYS keyboard /
}

static esp_err_t index_handler_home(httpd_req_t *req){
  httpd_resp_set_type(req, "text/html");    
  return httpd_resp_send(req, (const char *)INDEX_HTML_home, strlen(INDEX_HTML_home));//8088/KEYS keyboard /
}

//INDEX_HTML3 for cell phone api

int numchartowrite;
char variable[1600] = {0,};  //600
char ReturnSign;
size_t buf_len;  


static esp_err_t cmd_handler(httpd_req_t *req){ 
  char*  buf;
  numchartowrite=6;
  buf_len = httpd_req_get_url_query_len(req) + 1;
  if (buf_len > 1) {
    buf = (char*)malloc(buf_len);
    if(!buf){
      httpd_resp_send_500(req);
      return ESP_FAIL;
    }
    if (httpd_req_get_url_query_str(req, buf, buf_len) == ESP_OK) {
      if (httpd_query_key_value(buf, "go", variable, sizeof(variable)) == ESP_OK) {
      } else {
        free(buf);
        httpd_resp_send_404(req);
        return ESP_FAIL;
      }
    } else {
      free(buf);
      httpd_resp_send_404(req);
      return ESP_FAIL;
    }
    free(buf);
  } else {
    httpd_resp_send_404(req);
    return ESP_FAIL;
  }
  int res = 0;
  //////////////////////////////////   
  if(res){
    return httpd_resp_send_500(req);
  }   
  Runmode=0;    //STOP RUN PLC    
  ReturnSign=variable[2];
  if(variable[2]<0x60)
    ReturnSign=variable[2]+0x20;     //to lower case
  if(variable[0]=='k' && variable[1]=='e' && variable[2]=='y') //update cell key char
    {Serial.println("key");
      if(variable[3]=='s')
      {eewbyte(keychar,&variable[4],305);      //mobile.js   http://192.186.1.84:8088/KEYS            
      }
    if(variable[3]=='r') 
      {eerbyte(keychar,&variable[4],305);
      variable[3]='R'; 
      numchartowrite=310;
      }
    ReturnSign='y';   //numchartowrite default 6   
    }      
  if(variable[0]=='m' && variable[1]=='o' && variable[2]=='b') //mobile   
    {cellkeyboard();  //staticpromipcw.h local remote.js    
    numchartowrite=20;   //http://192.186.1.84:8088/MOB   feedback unchange   
    Runmode=1;   
    }
  if(variable[0]=='s' && variable[1]=='w' && variable[2]=='u') //switch simulation Tested
    {Runmode=10; 
    for(int t=0;t<10000;t++) //wait for limited time
       {delay(1);
       if(Runmode==1) //break when complete a cycle
          {//Serial.println("Runmode=10"); 
          break;
          }
       }    
    //switchsimulate(1);  
    ReturnSign='U';   
    }
  if(variable[0]=='M' && variable[1]=='Q' && variable[2]=='S') //MQTT Uploadsetup MQST Tested
    {systemsetup();         //http://192.186.1.84:8088/MQST    
    //Serial.println("MQSU");
    //Serial.println(variable);
    Runmode=1;    //RUN PLC    
    }  
  if(variable[0]=='M' && variable[1]=='C' && variable[2]=='K') //MQTT Uploadsetup MQST Tested
    {//systemsetup();         //http://192.186.1.84:8088/MQST    
    Serial.println("mqttconnected");
    Serial.println(mqttconnected);
    if(mqttconnected==1) variable[3]='Q';
    else  variable[3]='N';
     if(Runmode) variable[4]='S';
    else  variable[4]='S';
    Runmode=1;    //RUN PLC    
    }    
  /////////////////////////////////////////////////////////////////////////////////////    
  if(variable[0]=='t' && variable[1]=='x')  //uploadespStart
    {receivedplcdata();  
    if(variable[2]=='K')        
       Runmode=2;  
    }   
  if(variable[0]=='R' && variable[1]=='E' && variable[2]=='T') //PLC table sent back
    {receivedplcTable(); //download from PLC    
    }
  if(variable[0]=='t' && variable[1]=='y' && variable[2]=='F')  // 
    receivedplc(row5Data,540,variable[3],0);     //all 5  6 7           
  if(variable[0]=='t' && variable[1]=='y' && variable[2]=='G')  //   
    {receivedplc(row5Data,540,variable[3],540);  
    if(checkmqtt()==1 && variable[3]=='U') ReturnSign='m'; //check mqtt block exist 
    Runmode=2;                      
    }  
  if(variable[0]=='t' && variable[1]=='y' && variable[2]=='G' && variable[3]=='D')  //after download
      {Serial.println("txGD");    
        Runmode=1;  
      }
      
  //bypass download or comment upload//    
  variable[2]=ReturnSign;    
  httpd_resp_set_hdr(req, "Access-Control-Allow-Origin", "*");   
  return httpd_resp_send(req,variable,numchartowrite);   
  }

void starthttpServer(){
  httpd_config_t config = HTTPD_DEFAULT_CONFIG();
  config.server_port = 8088;
  httpd_uri_t index_uri = {
    .uri       = "/",
    .method    = HTTP_GET,
    .handler   = index_handler_phone,
    .user_ctx  = NULL
  };
//load mainpage //step3
  httpd_uri_t index_uri1 = {
      .uri       = "/lan",
      .method    = HTTP_GET,
      .handler   = index_handler_plc,
      .user_ctx  = NULL
    };
//setup cellphone key    
  httpd_uri_t index_uri2 = {
      .uri       = "/filehandle",
      .method    = HTTP_GET,
      .handler   = index_handler_filehandle,
      .user_ctx  = NULL
    };  
  
  httpd_uri_t index_uri3 = {
      .uri       = "/mqsetup",
      .method    = HTTP_GET,
      .handler   = index_handler_mqsetup,
      .user_ctx  = NULL
    };
  
  httpd_uri_t index_uri4 = {
      .uri       = "/mobile",
      .method    = HTTP_GET,
      .handler   = index_handler_mobile,
      .user_ctx  = NULL
    };
 
  httpd_uri_t index_uri5 = {
      .uri       = "/helppopup",
      .method    = HTTP_GET,
      .handler   = index_handler_helppopup,
      .user_ctx  = NULL
    };
  httpd_uri_t index_uri6 = {
      .uri       = "/home",
      .method    = HTTP_GET,
      .handler   = index_handler_home,
      .user_ctx  = NULL
    };
//      
//    
  httpd_uri_t cmd_uri = {
    .uri       = "/action",
    .method    = HTTP_GET,
    .handler   = cmd_handler,
    .user_ctx  = NULL
  };  
  
  if (httpd_start(&controller_httpd, &config) == ESP_OK) {   
    httpd_register_uri_handler(controller_httpd, &index_uri6);  //step4
    httpd_register_uri_handler(controller_httpd, &index_uri5);  //step4 
    httpd_register_uri_handler(controller_httpd, &index_uri4);  //step4
    httpd_register_uri_handler(controller_httpd, &index_uri3);  //step4
    httpd_register_uri_handler(controller_httpd, &index_uri2);
    httpd_register_uri_handler(controller_httpd, &index_uri1);
    httpd_register_uri_handler(controller_httpd, &index_uri);
    httpd_register_uri_handler(controller_httpd, &cmd_uri);
  }  
}
//********************************************************//
void downloadinit()
{initplc();         
  {netanalysis();       
    /*
    {byte x,y;
    for(y=0;y<ycount;y++) 
      {
      for(x=0;x<xcount;x++) 
        {Serial.print('/');
        Serial.print(netnum[x][y]);                  
        }
      Serial.println('=');   
      for(x=0;x<xcount;x++) 
        {Serial.print('-');
        Serial.print(BoxState[x][y].Linknum);                  
        }
      Serial.println('=');     
      }
    }       
    */
    //genlinktable();              
    ioinit(1);        //0 if not coolboot from 0 
    //Serial.println("Cool boot");   
    Runmode=1;              
  }
}                    
#ifdef ver3
void coolboot()
{pinMode(COOLBOOT,OUTPUT);
digitalWrite(COOLBOOT,LOW);
}
#endif
void setup(){          
  pinMode(setuppin,INPUT_PULLUP);
  pinMode(Enmqttclient,INPUT_PULLUP);
  WRITE_PERI_REG(RTC_CNTL_BROWN_OUT_REG, 0); //disable brownout detector 
  Serial.begin(115200);
  Serial.setDebugOutput(false); 
  Serial1.begin(115200, SERIAL_8N1, SERIAL1_TX_PIN, SERIAL1_RX_PIN);
  mqtten=digitalRead(Enmqttclient);  
  if(mqtten==1)  
    Serial.println("Mqtt switch is in enable position");  
  else
    Serial.println("Mqtt switch is in disable position");    
  ///////////////////////////////  
  Serial.println("PLC Maxtron");  
  eerpassid(eessid,mssid,mpass);
  Serial.println(mssid);
  Serial.println(mpass);  
  //pinMode(mqttbrokenpin,INPUT_PULLUP);
  //pinMode(mqttclientpin,INPUT_PULLUP);
  if(digitalRead(setuppin)==SETUPSTATE)  //setup mode
    {byte key; 
    setupmode=1;   
    eerbyte(0,&STXbuffer[1],50);
    SerialRTXLoop(STXbuffer,50);
    if(uartmaster(50)>40000)
      key=0;  
      Serial.print("Input ssid=");  
      do{if (Serial.available() > 0) {
        key = Serial.read();
        MYSSID=MYSSID+static_cast<char>(key);
        }
        }while(key!=0xd && key!=0xa);
      Serial.println(MYSSID);  
      key=0;
      Serial.print("Input password=");
      do{if (Serial.available() > 0) {
        key = Serial.read();
        MYPASSWORD=MYPASSWORD+static_cast<char>(key);
        }
        }while(key!=0xd && key!=0xa);           
    eerbyte(0,&STXbuffer[1],50);
    SerialRTXLoop(STXbuffer,50);
    if(uartmaster(50)>40000)
     Serial.println("Uart connect failure");    
    Serial.println(MYPASSWORD);  
    Serial.println("To run program set switch to run position and press reset to start program");
    Serial.println("To change SSID or password set switch setup position and press reset");
    MYSSID.toCharArray(mssid,MYSSID.length());
    MYPASSWORD.toCharArray(mpass,MYPASSWORD.length()); 
    eewpassid(eessid,mssid,mpass);
    //while (!Serial.available());
    while (digitalRead(setuppin)==SETUPSTATE);
    }
  else
    {
      #ifdef  BYPASSSETUP
      const char* ssid = "ATT3jl8Tns";
      const char* password = "6mrk8iyf26vn";
      WiFi.begin(ssid,password);
      #else
      //no setup auto start will store ssid and pws// 
      eerpassid(eessid,mssid,mpass);      
    //  WiFi.begin(&mssid[0],&mpass[0]);
      #endif
    }  
  //while (WiFi.status() != WL_CONNECTED) {
  //if(digitalRead(setuppin)!=SETUPSTATE)
  //  {delay(500);
  //  Serial.print(".");
  //  }
  //}
  //if(digitalRead(mqttclientpin)==0)     
  #ifdef    MQTTACTIVE     
  #ifdef   SWITCHTOBROKER
    brokersetup(1883);  
  #else  
      clientsetup(mqtten);//
  #endif  
  #endif  
  //if(digitalRead(mqttbrokenpin)==0)      
    //brokersetup(1883);      
  while(wificonnected==0) 
  {Serial.print('.');
  if(connectcount++>512)
      {Serial.println("Connect error");
      Serial.println("Unable to connect network, reenter check password and id"); //add check mqtt and bypass if necessory    
      }
  delay(10);
  }
  if(mqttconnected)
    Serial.println("Mqtt connected");         
  else
    Serial.println("Waiting for Mqtt connect");    
  Serial.println("WiFi connected");
  Serial.print("Maxtron PLC Ready! Go to: http://");
  Serial.println(WiFi.localIP());    
  // Start streaming web server
  starthttpServer();            
  eepromread(adddataz0,dataz0,0);     
  eepromread(adddataz1,dataz1,1);    
  eepromread(adddataz2,dataz2,1);    
  eepromread(adddataz3,dataz3,0);    
  eepromread(adddataz4,dataz4,2);   
  initplc();  
  netanalysis();    
  /*
  {byte x,y;
    for(y=0;y<ycount;y++) 
    {
    for(x=0;x<xcount;x++) 
      {Serial.print('/');
      Serial.print(netnum[x][y]);                  
      }
    Serial.println('=');   
    for(x=0;x<xcount;x++) 
      {Serial.print('-');
      Serial.print(BoxState[x][y].Linknum);                  
      }
    Serial.println('=');     
    }
  } 
  */         
  ioinit(1);  
  //////////HW COUNTER///////
  //Runmode=0;  //stop run PLC
  //attachInterrupt(digitalPinToInterrupt(counterPin), counterInterruptHandler, RISING);
  //////////HW COUNTER///////
  Runmode=1;  //after setup
}

void ioinit(byte type)
{for(byte h=0;h<8;h++)     
    {if(type==1) 
      {pinMode(Pinout[h],OUTPUT);     
      }
    digitalWrite(Pinout[h],HIGH);//high for no output LED common HIGH
    //analogWrite(Pinout[h],255);//high for no output LED common HIGH
    pinMode(Pinin[h],INPUT_PULLUP);  
    }  
}


void SerialRTXLoop(char* buffer,byte length)
{length=length+1;
STXbuffer[0]=0x5a;
Srxcount=0;
Serial1.write(STXbuffer,length);
}


uint16_t uartmaster(int length)     //master
{byte rxd;
length=length+1;
int y;
for(y=0;y<50000;y++)  
  {if (Serial1.available() && Srxcount<=length) {   
      rxd=Serial1.read();
      if(Srxcount==0 && rxd==0x5a) Srxcount=0;
      SRXbuffer[Srxcount] = rxd;         
      Serial.print(SRXbuffer[Srxcount],DEC);
      Srxcount++;       
      if(Srxcount>=length)          
      break;
      }  
  }  
  return y;  
}

void loop() {       
  if(Runmode==2)
    {Serial.println("IO init 2");  
      downloadinit(); 
    //coolboot();
    Runmode=1;
    }       
  if(Runmode==1)
  {for(uint32_t realtimeloop=0;realtimeloop<0x10000;realtimeloop++)      
    {runplc(realtimeloop);           
    if(Runmode==0)             
      {Serial.println("IO init 3"); 
      break;            
      }
    if(Runmode==10 && (realtimeloop&0x1ff)==0x1ff)  
      {switchsimulate(1);
      Runmode=1;
      }
    }
  }
}       




